# Keil uVision project P4.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: P4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: P4bVfinal_sanchezMillan.a51 P4aVfinal(1)_sanchezMillan.a51
