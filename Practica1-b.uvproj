# Keil uVision project Practica1-b.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Practica1-b +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: P1bV3_Romero+Sánchez.asm
