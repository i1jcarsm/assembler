# Keil uVision project P2b.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: P2b
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: P2cV1_Romero+Sánchez.asm
